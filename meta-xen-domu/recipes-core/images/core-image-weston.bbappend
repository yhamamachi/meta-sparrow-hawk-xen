# Add extra storage for disk test
## 1G: 1048576, 4G: 4194304, 6G: 6291456
IMAGE_ROOTFS_EXTRA_SPACE = "6291456"

