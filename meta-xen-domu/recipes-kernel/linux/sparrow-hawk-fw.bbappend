FILESEXTRAPATHS:prepend:sparrow-hawk = "${TOPDIR}/../../../../../firmware:"
