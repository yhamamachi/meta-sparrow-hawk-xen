COMPATIBLE_MACHINE = "(falcon|condor|eagle|whitehawk|grayhawk|sparrow-hawk)"
