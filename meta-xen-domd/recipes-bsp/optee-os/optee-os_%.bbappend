COMPATIBLE_MACHINE:append = "|sparrow-hawk"
OPTEEMACHINE="rcar"
