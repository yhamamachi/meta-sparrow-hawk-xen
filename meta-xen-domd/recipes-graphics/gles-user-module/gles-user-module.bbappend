COMPATIBLE_MACHINE:append = "|sparrow-hawk"
PV:r8a779g3 = "1.3.1"
BRANCH:r8a779g3 = "V4Hx/v1.3.1-2"
SRC_URI:r8a779g3 = "${GFX_URL}/raw/${BRANCH}/opengl/r8a779g0_linux_gsx_binaries_gles.tar.bz2;\
sha256sum=007cf0086ef58314511320977b1568064fbcad0d42f83543b588a2c09d39512a"
