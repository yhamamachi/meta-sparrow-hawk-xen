COMPATIBLE_MACHINE:append = "|sparrow-hawk"

