COMPATIBLE_MACHINE:append = "|sparrow-hawk"
PV:r8a779g3 = "1.3.1"
BRANCH:r8a779g3 = "V4Hx/v1.3.1-2"
SRC_URI:r8a779g3 = "${GFX_URL}/raw/${BRANCH}/gfxdrv/GSX_KM_V4H.tar.bz2;\
sha256sum=4d3749f0bcc8f7319fb2225fd6d3da9bacebd90f8a8ee6a48d4994f2e4ac5fd1"

KBUILD_DIR:r8a779g3 = "${S}/build/linux/r8a779g_linux"
KBUILD_OUTDIR:r8a779g3 = "binary_r8a779g_linux_nullws_drm_release/target_aarch64/kbuild"

